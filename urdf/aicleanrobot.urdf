Commit message: update aicleanrobot.urdf for x900

File: urdf/aicleanrobot.urdf (robot description, URDF)
Before this commit: robot aiclearnrobot, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=0.07 radius=0.167
